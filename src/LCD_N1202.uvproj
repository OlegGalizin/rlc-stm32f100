# Keil uVision project LCD_N1202.uvproj, settings and files
target LCD_N1202 (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD_N1202
  c flags: Optim=1
  c define: STM32F10X_LD_VL LCD_USART BIG LCDDEBUG
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ASM
    ./: startup_stm32f10x_ld_vl.s
  group C
    ./: n1202.c
