# Keil uVision project event.uvproj, settings and files
target Event_Demo (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: event
  c flags: Optim=1
  c define: STM32F10X_LD_VL MENU_DEMO LCD_USART
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ASM
    ./: startup_stm32f10x_ld_vl.s
  group C
    ./: event.c n1202.c
