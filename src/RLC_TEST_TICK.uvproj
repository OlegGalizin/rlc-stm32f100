# Keil uVision project RLC_TEST_TICK.uvproj, settings and files
target RLC_TEST (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RLC_TEST +hex
  c flags: Optim=4 wLevel=2
  c define: STM32F10X_LD_VL,BIG,LCD_USART,AUTO_RESET, MSE, TEST_CALIBR TEST_ADC TEST_TICK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ASM
    ./: startup_stm32f10x_ld_vl.s
  group C
    ./: adc.c n1202.c event.c sincos.c itoa.c menu.c display_float.c flash.c calcz.c out_float.c calibration.c main.c compl.c
